RDEPENDS:${PN} += "\
    nativesdk-wayland-tools \
    nativesdk-wayland-dev \
    nativesdk-compiler-rt	\
    nativesdk-coreutils \
    nativesdk-libcxx \
    nativesdk-lldb \
    nativesdk-wayland \
"