inherit custom-dev-image