inherit custom-image-base